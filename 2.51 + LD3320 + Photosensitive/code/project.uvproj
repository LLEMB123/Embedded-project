# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: XPT2046.c XPT2046.h Delay.h Delay.c ledss.h ledss.c main.c Timer0.c Timer0.h LCD1602.c LCD1602.h ld3320.c ld3320.h
